Commit message: working kinematics

File: 3dof/planar_real.urdf (robot description, URDF)
Before this commit: robot myrobot, 4 links, 3 joints
Links:
- link base_link: mass None -> 0.01
