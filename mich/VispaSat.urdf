Commit message: working vispa

File: mich/VispaSat.urdf (robot description, URDF)
Before this commit: robot VISPA, 8 links, 7 joints
Links:
- link Link_base: mass ${m} -> 500.0; geometry visual box size=0.8 0.8 0.8
